# Keil uVision project STM32F469_QSPI_N25Q128A.uvprojx, settings and files
target STM32F469_QSPI_N25Q128A (6190000::V6.19::ARMCLANG)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0-dev3
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F469_QSPI_N25Q128A
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N25Q128A
  c include: .\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\BSP\STM32469I-Discovery;.\Drivers\BSP\Components\n25q128a
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Flash Programming
    ./: FlashDev.c FlashPrg.c
  group Device
    ./: stm32F4xx_helper.c
  group Driver HAL
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_qspi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c
  group Driver BSP
    ./Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery_qspi.c
software components: CMSIS:CORE 5.6.0
