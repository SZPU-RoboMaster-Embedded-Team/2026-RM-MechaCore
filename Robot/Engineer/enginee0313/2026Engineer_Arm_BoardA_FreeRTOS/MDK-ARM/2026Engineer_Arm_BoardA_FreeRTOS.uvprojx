# Keil uVision project 2026Engineer_Arm_BoardA_FreeRTOS.uvprojx, settings and files
target 2026Engineer_Arm_BoardA_FreeRTOS (6230000::V6.23::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2026Engineer_Arm_BoardA_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Alg
    ../User/Alg/PID/: pid.cpp
    ../User/Alg/Filter/: Filter.cpp
    ../User/Alg/UtilityFunction/: SlopePlanning.hpp SlopPlanning.cpp
  group BSP
    ../User/BSP/Common/StateWatch/: buzzer_manager.cpp state_watch.cpp
    ../User/BSP/Motor/DM/: DmMotor.hpp
    ../User/BSP/Motor/: MotorBase.hpp
    ../User/BSP/RemoteControl/: DT7.cpp
    ../User/BSP/SimpleKey/: SimpleKey.hpp
  group HAL
    ../User/HAL/CAN/impl/: can_bus_impl.cpp can_device_impl.cpp
    ../User/HAL/CAN/interface/: can_bus.cpp can_device.cpp
    ../User/HAL/CAN/: can_hal.hpp
    ../User/HAL/UART/impl/: uart_bus_impl.cpp uart_device_impl.cpp
    ../User/HAL/UART/interface/: uart_bus.cpp uart_device.hpp
    ../User/HAL/UART/: uart_hal.hpp protocol_hal.hpp
    ../User/HAL/UART/protocol/: fifo_buffer.hpp protocol_builder.hpp protocol_packet.hpp protocol_parser.hpp protocol_processor.hpp protocol_rx_manager.cpp protocol_tx_manager.cpp
    ../User/HAL/DWT/: DWT.cpp
  group Task
    ../User/Task/: ArmControl.cpp Callback.cpp RemoteTask.cpp UartCom.cpp MotorTask.cpp RefereeTask.cpp
software components: CMSIS:CORE 6.1.0
