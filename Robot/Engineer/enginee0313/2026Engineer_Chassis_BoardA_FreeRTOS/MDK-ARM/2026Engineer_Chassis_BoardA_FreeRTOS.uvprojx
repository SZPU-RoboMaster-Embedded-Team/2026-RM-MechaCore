# Keil uVision project 2026Engineer_Chassis_BoardA_FreeRTOS.uvprojx, settings and files
target 2026Engineer_Chassis_BoardA_FreeRTOS (6220000::V6.22::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2026Engineer_Chassis_BoardA_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Alg
    ../User/core/Alg/ChassisCalculation/: CalculationBase.hpp MacanumCalculation.hpp
    ../User/core/Alg/Feedforward/: Feedforward.cpp
    ../User/core/Alg/PID/: pid.cpp
  group APP
    ../User/core/APP/Referee/: RM_RefereeSystem.cpp RM_RefereeSystem.h RM_RefereeSystemCRC.cpp RM_RefereeSystemCRC.h
  group BSP
    ../User/core/BSP/Common/StateWatch/: state_watch.cpp buzzer_manager.cpp
    ../User/core/BSP/Motor/: MotorBase.hpp
    ../User/core/BSP/Motor/Dji/: DjiMotor.hpp
    ../User/core/BSP/RemoteControl/: DT7.cpp
  group HAL
    ../User/core/HAL/CAN/: can_hal.hpp
    ../User/core/HAL/CAN/impl/: can_bus_impl.cpp can_device_impl.cpp
    ../User/core/HAL/CAN/interface/: can_bus.cpp can_device.cpp
    ../User/core/HAL/UART/impl/: uart_bus_impl.cpp uart_device_impl.cpp
    ../User/core/HAL/UART/interface/: uart_bus.cpp uart_device.hpp
    ../User/core/HAL/UART/: uart_hal.hpp
  group Task
    ../User/core/Task/: Callback.cpp ChassisTask.cpp MotorTask.cpp RemoteTask.cpp RefereeTask.cpp
software components: CMSIS:CORE 6.1.0
